# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\System;..\Hardware;..\Protocol;..\App
  group User
    ./: main.c
  group System
    ../System/: Delay.c Scheduler.c
  group Protocol
    ../Protocol/: I2C.c
  group Hardware
    ../Hardware/: MatrixKey.c Uart.c AT24C02.c OLED.c
  group App
    ../App/: MatrixKeyApp.c UartApp.c
